# Keil uVision project test-lpc810.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: LPC810M021 NXP (founded by Philips)
  cpu: IROM(0x00000000,0x1000) IRAM(0x10000000,0x0400) CPUTYPE("Cortex-M0+") CLOCK(30000000) ELITTLE
  output: cortextest
  group Source Group 1
    ./: main.c pos_cmsis.h noscfg.h poscfg.h testcfg.h sysinit.c
    ../common/: test.c
    ../../picoos-micro/: diag.c
  group picoos
    ../../picoos/src/pico/: fbit_gen.c picoos.c
    ../../picoos/src/nano/: n_bhalf.c n_conio.c n_core.c n_mem.c n_reg.c
    ../../picoos/ports/cortex-m/: arch_c.c port.h
  group New Group
    ../../cmsis-ports/lpc8xx/src/: chip_8xx.c sysinit_8xx.c syscon_8xx.c clock_8xx.c gpio_8xx.c
