# Keil uVision project test-lpc1343.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: cortextest
  group Source Group 1
    ./: main.c pos_cmsis.h noscfg.h poscfg.h gpio.c gpio.h driver_config.h
    ../common/: test.c
    ../../picoos-micro/: diag.c
  group picoos
    ../../picoos/src/pico/: fbit_gen.c picoos.c
    ../../picoos/src/nano/: n_bhalf.c n_conio.c n_core.c n_mem.c n_reg.c
    ../../picoos/ports/cortex-m/: arch_c.c port.h
  group cmsis
    ../../cmsis-collection/lpc13xx/src/: core_cm3.c system_LPC13xx.c
