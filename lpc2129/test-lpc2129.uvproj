# Keil uVision project test-lpc2129.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: picoos
  group test
    ./: noscfg.h poscfg.h main.c
    ../common/: test.c
  group lpc2xxx
    ../../picoos/ports/lpc2xxx/: lpc_reg.h arch.c timer.c uart.c low.s
    ./: uoscfg.h
  group picoos
    ../../picoos/src/nano/: n_core.c n_mem.c n_conio.c
    ../../picoos/src/pico/: fbit_gen.c picoos.c
  group picoos-micro
    ../../picoos-micro/: diag.c
