# Keil uVision project test-stm32.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cortextest
  group Source Group 1
    ./: main.c noscfg.h pos_cmsis.h poscfg.h stm32.ld
    ../common/: test.c
    ../../picoos-micro/: diag.c
  group picoos
    ../../picoos/src/pico/: fbit_gen.c picoos.c
    ../../picoos/src/nano/: n_bhalf.c n_conio.c n_core.c n_mem.c n_reg.c
    ../../picoos/ports/cortex-m/: arch_c.c port.h
  group cmsis
    ../../cmsis/stm32f10x/src/: core_cm3.c stm32f10x_gpio.c stm32f10x_rcc.c system_stm32f10x.c
