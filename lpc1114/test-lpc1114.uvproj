# Keil uVision project test-lpc1114.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: LPC1114/102 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: cortextest
  group Source Group 1
    ./: main.c pos_cmsis.h noscfg.h poscfg.h testcfg.h sysinit.c
    ../common/: test.c
    ../../picoos-micro/: diag.c
  group picoos
    ../../picoos/src/pico/: fbit_gen.c picoos.c
    ../../picoos/src/nano/: n_bhalf.c n_conio.c n_core.c n_mem.c n_reg.c
    ../../picoos/ports/cortex-m/: arch_c.c port.h con_lpc.c
  group New Group
    ../../cmsis-collection/lpc11cxx/src/: gpio_11xx_2.c sysinit_11xx.c sysctl_11xx.c clock_11xx.c chip_11xx.c uart_11xx.c ring_buffer.c
